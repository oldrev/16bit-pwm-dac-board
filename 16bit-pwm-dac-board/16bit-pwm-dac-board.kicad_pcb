# Repository oldrev/16bit-pwm-dac-board

File README.md:

# 16-bit PWM-DAC & PWM Charge Pump Eval-Board

## CREDITS:

* https://www.edn.com/combine-two-8-bit-outputs-to-make-one-16-bit-dac/

## KiCad design 16bit-pwm-dac-board/16bit-pwm-dac-board.kicad_pcb

Parts:
C101, C103, C104, C111, C118: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C102, C113, C117: 100u; CP_Radial_D8.0mm_P3.50mm
C105, C106, C109, C110, C112, C115: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C107: 5n6; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C108: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C114: 2n2; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C116, C119: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D101: SS14; D_SMA-SMB_Universal_Handsoldering
D102: GREEN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D103: RED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D104, D105, D106: 1N4148W; D_SOD-123
H101, H102, H103, H104: M3; MountingHole_3.5mm_Pad_Via
J101: CONN_9V_IN; Banana_Jack_1Pin
J102: CONN_GND; Banana_Jack_1Pin
J103: CONN_-5V_SW; PinHeader_1x02_P2.54mm_Vertical
J104: CONN_PWM_IN; PinHeader_1x04_P2.54mm_Vertical
J105: CONN_DAC_OUT_PINS; PinHeader_1x02_P2.54mm_Vertical
J106: CONN_DAC_OUT_BNC; BNC_Amphenol_031-6575_Horizontal
J107: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
NT101: NetTie_2; NetTie-2_SMD_Pad2.0mm
Q101, Q102: MMBT3904; SOT-23
R101, R102: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R103, R105: 3k92/0.1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R104, R106, R107: 1M/0.1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R108: 200k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R109: 200k/0.1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R110: 0R0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R111, R113, R114, R115: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R112: 220R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP101: TP_-5VOUT; TestPoint_Pad_D2.0mm
U101: 74LV14; SOIC-14_3.9x8.7mm_P1.27mm
U102: REF5025AD; SOIC-8_3.9x4.9mm_P1.27mm
U103: L78L05; SOT-89-3
U104: OPA2188; SOIC-8_3.9x4.9mm_P1.27mm
U105: 79L05; SOT-89-3

Connections:
+2V5: C109.1, C111.1, R110.2, U101.14 (3.3V)
+5V: C101.1, C106.1, C110.1, R111.1, U102.2 (Vin), U103.1 (OUT), U104.8 (V+)
+9V: C102.1, C104.1, D101.1 (K), J103.1, U103.3 (IN)
-5V: C119.2, D103.1 (K), J107.3, TP101.1, U105.3 (VO)
/DAC_OUT: C112.1, J105.1, J106.1 (In), R112.2
/PWM_HI: J104.1, R101.1, U101.1
/PWM_LO: J104.3, R102.1, U101.3
/PWM_NEG_IN: C114.1, R114.1
/VIN_9V: D101.2 (A), J101.1
/VREF_2V5: C103.1, C105.1, U102.6 (Vout), U104.3 (+)
GND: C102.2, C104.2, C106.2, C113.2, C114.2, C115.2, C117.1, C118.1, C119.1, D102.1 (K), D105.1 (K), H101.1, H102.1, H103.1, H104.1, J102.1, J104.2, J104.4, NT101.1, Q101.2 (E), R101.2, R102.2, R113.1, U103.2 (GND), U105.1 (GND)
GNDA: C101.2, C103.2, C105.2, C108.2, C109.2, C111.2, C112.2, J105.2, J106.2 (Ext), J107.1, NT101.2, U101.7 (GND), U102.4 (GND)
unnamed: C107.1, R109.2
unnamed: C107.2, C108.1, R108.2, U104.5 (+)
unnamed: C113.1, C115.1, J103.2, Q102.3 (C), R115.1
unnamed: C116.1, D104.2 (A), Q102.2 (E)
unnamed: C116.2, D105.2 (A), D106.1 (K)
unnamed: C117.2, C118.2, D106.2 (A), U105.2 (VI)
unnamed: D102.2 (A), R111.2
unnamed: D103.2 (A), R113.2
unnamed: D104.1 (K), Q101.3 (C), Q102.1 (B), R115.2
unnamed: Q101.1 (B), R114.2
unnamed: R103.1, U101.2, U101.5, U101.9, U101.13
unnamed: R103.2, R107.2, R109.1
unnamed: R104.1, R107.1, U101.4, U101.11
unnamed: R104.2, R105.1, U101.6, U101.8, U101.12
unnamed: R105.2, R106.2, R108.1
unnamed: R106.1, U101.10
unnamed: R110.1, U104.1, U104.2 (-)
unnamed: R112.1, U104.6 (-), U104.7
VEE: C110.2, J107.2, U104.4 (V-)

Notes on the sheet:
GND 与负电压选择

Board: 2 copper layers, 80.0 x 50.0 mm, 60 parts (1 on the bottom side), 31 nets.

## Commit log

2021-03-31 init

Notices in the files:
16bit-pwm-dac-board/16bit-pwm-dac-board.kicad_pcb:
© 2021, BST YN
